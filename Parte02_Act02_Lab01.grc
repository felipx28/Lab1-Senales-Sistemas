options:
  parameters:
    generate_options: qt_gui
    id: Actividad08
    output_language: python
    title: test08
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '11000'
  states: {}
- name: var01
  id: variable_qtgui_range
  parameters:
    start: '5000'
    step: '1'
    stop: '32000'
    value: '11000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/fernanda/Escritorio/muestras_guitarra/acoustic.wav
    repeat: 'True'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '2'
    taps: '1'
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_throttle_0, '0', audio_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
