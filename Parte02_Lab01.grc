options:
  parameters:
    generate_options: qt_gui
    id: Actividad07
    output_language: python
    title: test07
  states: {}

blocks:
- name: var01
  id: variable_qtgui_range
  parameters:
    start: '500'
    step: '1000'
    stop: '50000'
    value: '11000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: var01
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: var01
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/fernanda/Escritorio/muestras_guitarra/acoustic.wav
    repeat: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: var01
    type: float
  states: {}

connections:
- [blocks_throttle_0, '0', audio_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
